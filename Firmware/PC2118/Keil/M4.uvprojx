# Keil uVision project M4.uvprojx, settings and files
target LPC4337_M4_IntFlash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.7.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: M4
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: \Keil_v5\Projects\PC2118\Keil\RTOS\Source\include;\Keil_v5\Projects\PC2118\Keil\Drivers\include;.\Core\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\M4.sct
  group Startup
    ./StartupM4/: startup_LPC43xx.s system_LPC43xx.c
  group RTOS
    ./RTOS/Source/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group Application
    ./: mainM4.c rtos.c utils.c
  group Drivers
    ./Drivers/source/: lpc43xx_cgu.c lpc43xx_emc.c lpc43xx_gpio.c lpc43xx_scu.c
