# Keil uVision project M0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC4337:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.7.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: M0
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
